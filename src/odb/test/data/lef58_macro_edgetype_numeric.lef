VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

PROPERTYDEFINITIONS
  MACRO LEF58_EDGETYPE STRING ;
END PROPERTYDEFINITIONS

MACRO CELL_NUMERIC_EDGE
  PROPERTY LEF58_EDGETYPE "
  EDGETYPE LEFT 2 ;
  EDGETYPE RIGHT 2 ;
  EDGETYPE TOP G2 RANGE 0.5 1.5 ;
  EDGETYPE BOTTOM TYPE1 ;
  " ;
END CELL_NUMERIC_EDGE

END LIBRARY
