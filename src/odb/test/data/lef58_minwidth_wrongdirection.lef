VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MANUFACTURINGGRID 0.001 ;

PROPERTYDEFINITIONS
  LAYER LEF58_MINWIDTH STRING ;
END PROPERTYDEFINITIONS

LAYER M4
  TYPE ROUTING ;
  DIRECTION HORIZONTAL ;
  WIDTH 0.5 ;
  PROPERTY LEF58_MINWIDTH "
    MINWIDTH 1.0 WRONGDIRECTION ; " ;
END M4

END LIBRARY
