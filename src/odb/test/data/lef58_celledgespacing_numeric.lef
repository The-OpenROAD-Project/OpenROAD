VERSION 5.8 ;
NAMESCASESENSITIVE ON ;

PROPERTYDEFINITIONS
    LIBRARY LEF58_CELLEDGESPACINGTABLE STRING
      "CELLEDGESPACINGTABLE
        EDGETYPE 1 1 0.400
        EDGETYPE 1 G2 0.200
        EDGETYPE G1 G1 0.100 ;" ;
END PROPERTYDEFINITIONS

UNITS
    DATABASE MICRONS 1000 ;
END UNITS

LAYER metal1
    TYPE ROUTING ;
    WIDTH 0.1 ;
END metal1

END LIBRARY
