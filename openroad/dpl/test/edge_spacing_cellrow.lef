VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

SITE HalfHeightSite
  CLASS CORE ;
  SYMMETRY Y ;
  SIZE 0.19 BY 0.7 ;
END HalfHeightSite

MACRO MOCK_SINGLE_EDGE_2
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.38 BY 1.4 ;
  SYMMETRY X Y ;
  SITE FreePDK45_38x28_10R_NP_162NW_34O ;
  PROPERTY LEF58_EDGETYPE "
    EDGETYPE LEFT VERTICAL_EDGE_2 ; " ;
END MOCK_SINGLE_EDGE_2

END LIBRARY
