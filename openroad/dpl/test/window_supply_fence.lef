VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 2000 ;
END UNITS
MANUFACTURINGGRID 0.001 ;
LAYER metal1
  TYPE ROUTING ;
  DIRECTION HORIZONTAL ;
  PITCH 1 ;
  WIDTH 0.1 ;
  SPACING 0.1 ;
END metal1
SITE REVIEW_SINGLE_SITE
  CLASS CORE ;
  SYMMETRY X Y ;
  SIZE 1 BY 1 ;
END REVIEW_SINGLE_SITE
MACRO REVIEW_WIDE
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 10 BY 1 ;
  SYMMETRY X Y ;
  SITE REVIEW_SINGLE_SITE ;
END REVIEW_WIDE
MACRO REVIEW_MEMBER
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2 BY 1 ;
  SYMMETRY X Y ;
  SITE REVIEW_SINGLE_SITE ;
END REVIEW_MEMBER
END LIBRARY
