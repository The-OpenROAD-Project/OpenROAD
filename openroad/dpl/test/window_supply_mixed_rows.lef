VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 2000 ;
END UNITS
MANUFACTURINGGRID 0.001 ;
LAYER metal1
  TYPE ROUTING ;
  DIRECTION HORIZONTAL ;
  PITCH 1 ;
  WIDTH 0.1 ;
  SPACING 0.1 ;
END metal1
SITE REVIEW_SINGLE_SITE
  CLASS CORE ;
  SYMMETRY X Y ;
  SIZE 1 BY 1 ;
END REVIEW_SINGLE_SITE
SITE REVIEW_DOUBLE_SITE
  CLASS CORE ;
  SYMMETRY X Y ;
  SIZE 1 BY 2 ;
END REVIEW_DOUBLE_SITE
MACRO REVIEW_SHORT
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 2 BY 1 ;
  SYMMETRY X Y ;
  SITE REVIEW_SINGLE_SITE ;
END REVIEW_SHORT
MACRO REVIEW_TALL
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 4 BY 2 ;
  SYMMETRY X Y ;
  SITE REVIEW_DOUBLE_SITE ;
END REVIEW_TALL
END LIBRARY
