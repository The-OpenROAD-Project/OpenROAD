VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MANUFACTURINGGRID 0.01 ;

PROPERTYDEFINITIONS
  LAYER LEF58_MINSTEP STRING ;
END PROPERTYDEFINITIONS

LAYER IMP1
  TYPE IMPLANT ;
  WIDTH 3.5 ;
  SPACING 1.5 ;
  PROPERTY LEF58_MINSTEP "
    MINSTEP 4.8 MINADJACENTLENGTH 2.4 ; " ;
END IMP1

END LIBRARY
