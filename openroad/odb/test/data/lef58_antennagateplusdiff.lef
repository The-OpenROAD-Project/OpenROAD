VERSION 5.8 ;
NAMESCASESENSITIVE ON ;

PROPERTYDEFINITIONS
    LAYER LEF58_ANTENNAGATEPLUSDIFF STRING ;
END PROPERTYDEFINITIONS

UNITS
    DATABASE MICRONS 1000 ;
END UNITS

LAYER metal1
    TYPE ROUTING ;
    WIDTH 0.1 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNACUMDIFFAREARATIO 5000 ;
    PROPERTY LEF58_ANTENNAGATEPLUSDIFF "ANTENNAGATEPLUSDIFF OXIDE1 0.5 ; " ;
    ANTENNAMODEL OXIDE2 ;
    PROPERTY LEF58_ANTENNAGATEPLUSDIFF "ANTENNAGATEPLUSDIFF OXIDE2 PWL ( ( 1.0 2.0 ) ( 3.0 4.0 ) ) ; " ;
END metal1

END LIBRARY
