VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO L_BLOCK
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  FOREIGN L_BLOCK 0 0 ;
  SIZE 25.2 BY 25.2 ;
  SYMMETRY X Y R90 ;
  OBS
    LAYER metal1 ;
      RECT 0 0 25.2 5.6 ;
      RECT 0 5.6 5.6 25.2 ;
    LAYER metal2 ;
      RECT 0 0 25.2 5.6 ;
      RECT 0 5.6 5.6 25.2 ;
    LAYER metal3 ;
      RECT 0 0 25.2 5.6 ;
      RECT 0 5.6 5.6 25.2 ;
    LAYER OVERLAP ;
      RECT 0 0 25.2 5.6 ;
      RECT 0 5.6 5.6 25.2 ;
  END
END L_BLOCK

END LIBRARY
